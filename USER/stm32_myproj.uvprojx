# Keil uVision project stm32_myproj.uvprojx, settings and files
target stm32_myproj (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_myproj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c delay.c delay.h keyboard.c keyboard.h oled.c oled.h oledfont.c oledfont.h timer.c timer.h usart.c usart.h adc.h adc.c sensor.c sensor.h assist.c assist.h
